# IAR project customized_128bitservice.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 Freescale MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; IAR
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: ../app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../middleware/wireless/framework_5.3.2/XCVR/MKW41Z4; ../../../../../../../middleware/wireless/framework_5.3.2/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.2/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/SecLib; ../../../../../../../middleware/wireless/framework_5.3.2/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/OSAbstraction/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.2/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/MWSCoexistence/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/LowPower/Interface/MKW41Z; ../../../../../../../middleware/wireless/framework_5.3.2/LowPower/Interface/MKW41Z; ../../../../../../../middleware/wireless/framework_5.3.2/Lists; ../../../../../../../middleware/wireless/framework_5.3.2/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/GPIO; ../../../../../../../middleware/wireless/framework_5.3.2/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.2/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.2/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/Common; ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/temperature; ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/battery; ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/config; ../../../../../../../middleware/wireless/bluetooth_1.2.2/hci_transport/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/temperature_sensor; ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/gatt_db/macros; ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common; ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common; ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common; ../../../../../../../middleware/wireless/bluetooth_1.2.2/controller/interface; ../../../../common; ../../../../../../../devices/MKW41Z4/utilities; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../devices/MKW41Z4; ../../../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkOutputFile: temperature_sensor_BM.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../../middleware/wireless/framework_5.3.2/Common/devices/MKW41Z4/linker/iar/MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/lib/ble_4-2_host_peripheral_cm0p_IAR.a; ../../../../../../../middleware/wireless/framework_5.3.2/SecLib/lib_crypto_IAR_M0.a; ../../../../../../../middleware/wireless/bluetooth_1.2.2/controller/lib/ble_kw41z_controller_lib_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKW41Z512VHT4; IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.2/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/Reset/: Reset.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.2/Common/: EmbeddedTypes.h FwkInit.c
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/Messaging/Source/: Messaging.c
  group framework/LowPower/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/LowPower/Interface/MKW41Z/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/LowPower/Source/MKW41Z/: PWR.c PWRLib.c PWRLib.h PWR_BLE.c PWR_BLE.h
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h
  group framework/OSAbstraction/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/OSAbstraction/Source/: fsl_os_abstraction_bm.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/RNG/Source/: RNG.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Source/: SerialManager.c UART_Adapter.h UART_Adapter.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.2/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.2/Lists/: GenericList.c GenericList.h
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.2/ModuleInfo/: ModuleInfo.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.2/SecLib/: SecLib.h SecLib.c
  group framework/XCVR/MKW41Z4
    ../../../../../../../middleware/wireless/framework_5.3.2/XCVR/MKW41Z4/: fsl_xcvr.c fsl_xcvr.h fsl_xcvr_ble_config.c fsl_xcvr_ant_config.c fsl_xcvr_zgbe_config.c fsl_xcvr_msk_config.c fsl_xcvr_common_config.c ifr_radio.c ifr_radio.h fsl_xcvr_mode_datarate_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c fsl_xcvr_trim.c fsl_xcvr_trim.h dbg_ram_capture.c dbg_ram_capture.h
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/MWSCoexistence/Source/: MWS.c
  group framework/DCDC/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/DCDC/Source/: DCDC.c
  group bluetooth/host/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/interface/: att_errors.h ble_constants.h ble_general.h ble_sig_defines.h ble_host_tasks.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_interface.h gatt_server_interface.h gatt_types.h gatt_db_dynamic.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_types.h smp_types.h vendor_debug_commands.h
  group bluetooth/host/config
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/config/: ble_config.h ble_globals.c
  group bluetooth/controller/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/profiles/battery
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/battery/: battery_service.c
  group bluetooth/profiles/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/battery/: battery_interface.h
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/device_info/: device_info_interface.h
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/temperature/: temperature_interface.h
  group bluetooth/profiles/device_info
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/device_info/: device_info_service.c
  group bluetooth/profiles/temperature
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/temperature/: temperature_service.c
  group app/common
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/: ble_host_tasks.c ble_host_task_config.h ble_conn_manager.c ble_conn_manager.h ble_controller_task.c ble_controller_task_config.h ApplMain.c ApplMain.h ble_init.c ble_init.h
  group app/common/gatt_db
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group app/common/gatt_db/macros
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/gatt_db/macros/: gatt_alloc_x.def gatt_db_macros.h gatt_db_x_macros.def gatt_decl_x.def gatt_enum_x.def gatt_init_x.def gatt_size_x.def gatt_uuid_decl_x.def gatt_uuid_def_x.def
  group app/temperature_sensor
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/temperature_sensor/: app.c app.h app_config.c gatt_db.h gatt_uuid128.h
    ../: app_preinclude.h
  group doc
    ../../: readme.txt
  group startup
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_cop.c fsl_cop.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_edma.c fsl_edma.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_ltc.c fsl_ltc.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rtc.c fsl_rtc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_tpm.c fsl_tpm.h fsl_trng.c fsl_trng.h fsl_tsi_v4.c fsl_tsi_v4.h
  group board
    ../../../../common/: board.c board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
